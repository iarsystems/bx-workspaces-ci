# IAR project library.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCIncludePath2: ../portable/library
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: library.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: lnkrx600.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group (top)
    ../portable/library/: crc32.c debug_log.c divisionByZero.c math_log.c math_mul.c math_sum.c nullAssign.c unreachableCode.c
