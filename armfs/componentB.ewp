# IAR project componentB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\portable\library
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: componentB.out
  ILINK.IlinkIcfFile: generic_cortex.icf
  ILINK.IlinkAdditionalLibs: $EXE_DIR$\library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../portable/componentB/: componentB.c
