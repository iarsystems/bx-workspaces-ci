# IAR project library.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: library.out
  group (top)
    ../portable/library/: arrayOutOfBounds.c bufferOverflow.c debug_log.c divisionByZero.c doInit.c evalOrder.c integerOverflow.c library.h math_mul.c math_sum.c memoryLeaks.c nullPointerDerefBenchmark.c unreachableCode.c
