<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\library.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\componentA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\componentB.ewp</path>
    </project>
    <batchBuild />
</workspace>
