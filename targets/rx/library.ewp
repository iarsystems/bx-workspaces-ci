# IAR project library.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCIncludePath2: ../..
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: library.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../library/source/: crc16.c crc32.c
