# IAR project library.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: RV32 RV32
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCIncludePath2: ../..
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: library.out
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../library/source/: crc16.c crc32.c
