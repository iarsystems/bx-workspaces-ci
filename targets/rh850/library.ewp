# IAR project library.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: UnspecifiedG3M RH850 G3M - Unspecified
  General.GHeapSize: 0x1000
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCIncludePath2: ../..
  ILINK.IlinkOutputFile: library.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RH850)
  as the first configuration, except:
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../library/source/: crc16.c crc32.c
